options:
  parameters:
    author: ctn008
    generate_options: qt_gui
    id: tetraDMO_Decoder_v1
    output_language: python
    title: tetraDMO_Decoder_v1
  states: {}

blocks:
- name: next_view
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: view_step
  id: variable
  parameters:
    value: 520*1
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ctn008/0.Pluto/pluto_04_analysis/RxDMO_pluto_to_s36kBit_04.uint8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      """

      import numpy as np
      from gnuradio import gr


      class tetraChDecoder(gr.sync_block):
          
          def __init__(self, example_param=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Tetra ACELP\nChannel Decoder',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.example_param = example_param

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!

      dmoBurstSync
      - input is a stream of demodulated bits (each bit in one byte)
      - output is a stream of consecutive 510 bits (bytes) after burst synchronisation is detected.
      - consider to pass tag along the data stream to indicate the type of burst ? Alternatively, can use 34 guard bit as a burst header to fill in the necessary info or even use extra bytes (on top of 510 bytes) as burst header. Using burst header has the advantage of these headers can be stored together with data streams in output files, maybe more convenient & easy for debug.
      """

      import numpy as np
      from gnuradio import gr

      DSB = 1
      DNB = 2
      DNB_SF = 3
      INACTIVE = 0
      BURST_IN = 510
      BURST_OUT = 680

      class dmoBurstSync(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          NORMAL_TRAINING_SEQ_1       = (1,1,0,1,0,0,0,0,1,1,1,0,1,0,0,1,1,1,0,1,0,0)  # n1..n22
          NORMAL_TRAINING_SEQ_2       = (0,1,1,1,1,0,1,0,0,1,0,0,0,0,1,1,0,1,1,1,1,0)  # p1..p22
          NORMAL_TRAINING_SEQ_3_BEGIN = (0,0,0,1,1,0,1,0,1,1,0,1)                      # q11..q22
          NORMAL_TRAINING_SEQ_3_END   = (1,0,1,1,0,1,1,1,0,0)                          # q1..q10

          SYNC_TRAINING_SEQ = (1,1,0,0,0,0,0,1,1,0,0,1,1,1,0,0,1,1,1,0,1,0,0,1,1,1,0,0,0,0,0,1,1,0,0,1,1,1)  # y1..y38

          PREAMBLE_P1  =   (0,0,1,1,0,0,1,0,0,0,1,1)    # j1..j12
          PREAMBLE_P2  =   (1,0,0,1,1,0,1,0,1,0,0,1)    # k1..k12
          PREAMBLE_P3  =   (0,0,0,1,0,1,0,0,0,1,1,1)    # I1..I12

          BURST_DETECT_THRESHOLD = 6;

          def patternAtPositionScore(self, bitstream, pattern, position):
              patternScore = 0
              for i in range(len(pattern)):
                  if bitstream[position+i] != pattern[i]:
                      patternScore += 1
              return patternScore

          def isValidBurst(self, bitstream, index, pointer):
              
              score_preamble_p1 = self.patternAtPositionScore(bitstream, dmoBurstSync.PREAMBLE_P1, index + pointer+34)   # don't count 34 guard bits, starts @ zero
              score_preamble_p2 = self.patternAtPositionScore(bitstream, dmoBurstSync.PREAMBLE_P2, index + pointer+34)   # don't count 34 guard bits
              score_preamble_p3 = self.patternAtPositionScore(bitstream, dmoBurstSync.PREAMBLE_P3, index + pointer+34)   # don't count 34 guard bits

              scoreSync    = self.patternAtPositionScore(bitstream, dmoBurstSync.SYNC_TRAINING_SEQ,     214 + index + pointer+34) # STS position DMO burst
              scoreNormal1 = self.patternAtPositionScore(bitstream, dmoBurstSync.NORMAL_TRAINING_SEQ_1, 230 + index + pointer+34) # NTS1 position DMO burst
              scoreNormal2 = self.patternAtPositionScore(bitstream, dmoBurstSync.NORMAL_TRAINING_SEQ_2, 230 + index + pointer+34) # NTS2 position DMO burst
           
              scoreNormal1 = int((scoreNormal1*38)/22)                                       # multifly with 1.5 to be comparable with STS
              scoreNormal2 = int((scoreNormal2*38)/22) 

              scoreNormal1 += score_preamble_p1                                              # combine bit errors of preamble & training sequences
              scoreNormal2 += score_preamble_p2 
              scoreSync    += score_preamble_p3 

              # soft decision to detect burst: bit errors in preamble & training sequence less than 6
              scoreMin = scoreSync                                                   # if same score, Sync Burst is chosen
              burstType = DSB         

              if (scoreNormal1 < scoreMin):
                  scoreMin  = scoreNormal1 
                  burstType = DNB 
              if (scoreNormal2 < scoreMin):
                  scoreMin  = scoreNormal2 
                  burstType = DNB_SF 

              if (scoreMin > dmoBurstSync.BURST_DETECT_THRESHOLD):                  # frame (burst) is matched and can be processed
                  burstType = INACTIVE
                  
              return (burstType, scoreMin)

          def __init__(self, dmoMode = True): 
              gr.basic_block.__init__(
                  self,
                  name='dmoBurst\nDetect-Sync',     # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.dmoMode = dmoMode       # False means tmoMode
              self.burstActive = False
              self.burstSynced = False
              self.firstDetect = 0
              self.in_pointer = 0        

          def general_work(self, input_items, output_items):

              in_index = 0
              out_index = 0

              while (len(input_items[0]) >= in_index + BURST_IN) and (len(output_items[0]) >= out_index + BURST_OUT):
                  # only process the code below if more than 510 input data samples
                  if (not self.burstSynced):
                      for i in range(len(input_items[0]) - in_index - BURST_IN ): 
                          (burstType, scoreMin) = self.isValidBurst(input_items[0], in_index, i)

                          if (burstType):
                              self.burstSynced = True
                              self.firstDetect = self.in_pointer
                              break   # break for loop if validBurst found
                          self.in_pointer += 1
                      in_index += i
                  else:          
                      (burstType, scoreMin) = self.isValidBurst(input_items[0], in_index, 0)
                      if (burstType):
                          self.burstActive = True
                      else:
                          self.burstActive = False

                      output_items[0][out_index] = burstType
                      output_items[0][out_index+1] = scoreMin
                      output_items[0][out_index+2:out_index+10] = np.array([0]*8, dtype = 'uint8')
                      if burstType :
                          output_items[0][out_index+10:out_index+520] = input_items[0][in_index:in_index+BURST_IN]
                      else:
                          output_items[0][out_index+10:out_index+520] = np.array([0]*BURST_IN, dtype = 'uint8')
                      in_index += BURST_IN
                      self.in_pointer += BURST_IN
                      out_index += 520
              self.consume(0, in_index) #consume port 0 input
              return out_index
    comment: (10+510) burst
    dmoMode: 'True'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          
          def __init__(self, example_param=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.example_param = example_param

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class frameStep(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, step = 4800, change = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Push_per_Frame',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.step= step
              self.change = change
              self.prechange = False

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              next_view = False
              if self.change != self.prechange :
                  #print("Next View")
                  next_view = True
                  self.prechange = self.change
              if next_view and (len(output_items[0]) >= self.step) and (len(input_items[0]) >= self.step):
                  output_items[0][:self.step] = input_items[0][:self.step]
                  #DEBUG output_txt = ''
                  #DEBUG for i in range(self.step):
                  #DEBUG output_txt += '1' if output_items[0][i] else '0'
                  self.consume(0, self.step)
                  #DEBUG print (output_txt)
                  return self.step
              else:
                  return 0
    change: next_view
    step: view_step
  states: {}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      """

      import numpy as np
      from gnuradio import gr


      class speechDeccoder(gr.sync_block):
          
          def __init__(self, example_param=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Tetra ACELP\nSpeech Decoder',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.int16]
              )
              self.example_param = example_param

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      DSB = 1
      DNB = 2
      DNB_SF = 3
      INACTIVE = 0
      BURST_IN = 520
      FRAME_OUT = 480

      class tetraTime():
          def __init__(self):
              self.tn = 1
              self.fn = 1
              self.mn = 1
          def timeIncrease(self):
              self.tn += 1
              if self.tn > 4:
                  self.tn -= 4
                  self.fn += 1
              if self.fn > 18:
                  self.fn -= 18
                  self.mn += 1
              
      class tetraCell():
          def __init__(self):
              self.m_mcc               = 0
              self.m_mnc               = 0
              self.m_colorCode         = 0
              self.m_scramblingCode    = 0
              self.m_locationArea      = 0

              self.m_downlinkFrequency = 0
              self.m_uplinkFrequency   = 0

              self.m_cellInformationsAcquired = False
              
          def updateScramblingCode(self, sourceAddress, mnIdentity): 
              self.m_mcc = mnIdentity >> 14
              self.m_mnc = mnIdentity & 0x3ff

              self.m_scramblingCode = sourceAddress | ((mnIdentity & 0x003f) << 24)
              self.m_scramblingCode = (self.m_scramblingCode << 2) | 0x0003

              self.m_cellInformationsAcquired = True

          def getScramblingCode(self):
              return self.m_scramblingCode

      class lowerMac(gr.basic_block):
          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.uint8, ndim=1,flags="C")
          lib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Receiver/codingLib.so') # class level loading lib
          lib.descramble_raw.argtypes = [ND_POINTER, c_size_t, ND_POINTER, c_size_t, c_size_t]
          lib.descramble_raw.restype = c_size_t
          lib.deinterleave_raw.argtypes = [ND_POINTER, c_size_t, ND_POINTER, c_size_t, c_size_t]
          lib.deinterleave_raw.restype = c_size_t
          lib.depuncture23_raw.argtypes = [ND_POINTER, c_size_t, ND_POINTER, c_size_t]
          lib.depuncture23_raw.restype = c_size_t
          lib.viterbiDecode1614_raw.argtypes = [ND_POINTER, c_size_t, ND_POINTER]
          lib.viterbiDecode1614_raw.restype = c_size_t
          lib.checkCrc16Ccitt_raw.argtypes = [ND_POINTER, c_size_t, c_size_t]
          lib.checkCrc16Ccitt_raw.restype = c_bool
          

          def descramble(data, size, scramblingCode):
              res = np.array([0]*size, dtype='uint8')
              res_len = lowerMac.lib.descramble_raw(data, len(data), res, size, scramblingCode)
              return res

          def deinterleave(data, K, a):
              res = np.array([0]*K, dtype='uint8')
              res_len = lowerMac.lib.deinterleave_raw(data, len(data), res, K, a)
              return res
              
          def depuncture23(data, length):
              res = np.array([0]*(4*length*2//3), dtype='uint8')
              res_len = lowerMac.lib.depuncture23_raw(data, len(data), res, length)
              return res

          def viterbiDecode1614(data):
              res = np.array([0]*(len(data)//4), dtype='uint8')
              res_len = lowerMac.lib.viterbiDecode1614_raw(data, len(data), res)
              return res

          def checkCrc16Ccitt(data, length):
              res_value = lowerMac.lib.checkCrc16Ccitt_raw(data, len(data), length)
              return res_value

          def getValue(pdu, pos, len):
              temp = 0
              for i in range(len):
                  temp = temp * 2 + pdu[pos+i]
              return temp
          
          def __init__(self, mode= True):
              gr.basic_block.__init__(
                  self,
                  name='serviceLowerMAC\nserviceUpperMAC',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.mode = mode
              self.burst_cnt = 0
              self.commType = 0

              self.m_tetraTime = tetraTime()
              self.m_tetraCell = tetraCell()
              self.m_sfStolenFlag = False
              
              self.fragFlag = 0
              self.destinAddrType = 0
              self.destinAddress  = 0
              self.sourceAddrType = 0
              self.sourceAddress  = 0
              self.mnIdentity     = 0
                 
          def processDmacSync(self, pdu):
              self.commType       = lowerMac.getValue(pdu, 6, 2)
              self.m_tetraTime.tn = lowerMac.getValue(pdu, 12, 2) + 1
              self.m_tetraTime.fn = lowerMac.getValue(pdu, 14, 5)
              self.fragFlag       = lowerMac.getValue(pdu, 71, 1)

              #DEBUG print("TN:FN", self.m_tetraTime.tn,':', self.m_tetraTime.fn, " fragFlag: ", self.fragFlag)
              
              pos = 76 if self.fragFlag else 72
              self.frameCntDn     = lowerMac.getValue(pdu, pos, 2)
              pos += 2
              self.destinAddrType = lowerMac.getValue(pdu, pos, 2)
              pos += 2
              if self.destinAddrType != 2:
                  self.destinAddress = lowerMac.getValue(pdu, pos, 24)
                  pos += 24
              self.sourceAddrType = lowerMac.getValue(pdu, pos, 2)
              pos += 2
              if self.sourceAddrType != 2:
                  self.sourceAddress = lowerMac.getValue(pdu, pos, 24)
                  pos += 24
              if (self.commType == 0) or (self.commType == 1):
                  self.mnIdentity = lowerMac.getValue(pdu, pos, 24)
                  pos += 24
              if self.mnIdentity and self.sourceAddress :
                  self.m_tetraCell.updateScramblingCode(self.sourceAddress, self.mnIdentity)

              #DEBUG print("Scrambling code: ", hex(self.m_tetraCell.getScramblingCode()) )
              #DEBUG print("Source address: ", self.sourceAddress, "Destin address: ", self.destinAddress)
              
          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0
              while len(input_items[0]) - in_index >= BURST_IN:
                  print("MN:FN:TN = ", self.m_tetraTime.mn,":",self.m_tetraTime.fn,":",self.m_tetraTime.tn, " ", end ='')
                  if input_items[0][in_index] == DSB:
                      bkn1 = np.array(input_items[0][in_index+10+34+94 :in_index+10+34+94 +120])
                      bkn2 = np.array(input_items[0][in_index+10+34+252:in_index+10+34+252+216])

                      bkn1 = lowerMac.descramble(bkn1, 120, 0x03)
                      bkn1 = lowerMac.deinterleave(bkn1, 120, 11)
                      bkn1 = lowerMac.depuncture23(bkn1, 120)
                      bkn1 = lowerMac.viterbiDecode1614(bkn1)

                      bkn2 = lowerMac.descramble(bkn2, 216, 0x03)
                      bkn2 = lowerMac.deinterleave(bkn2, 216, 101)
                      bkn2 = lowerMac.depuncture23(bkn2, 216)
                      bkn2 = lowerMac.viterbiDecode1614(bkn2)

                      bkn1crc = lowerMac.checkCrc16Ccitt(bkn1, 76)
                      bkn2crc = lowerMac.checkCrc16Ccitt(bkn2, 140)
                      
                      if (bkn1crc==False) or (bkn2crc==False):
                          print("DSB ", "CRC: ", bkn1crc, bkn2crc)
                      else:
                          print("DSB")
                          bkn1 = np.concatenate((bkn1[:60], bkn2[:124]))
                          self.processDmacSync( bkn1 )

                          """ bkn1_txt = ''
                          for i in range(len(bkn1)):
                              bkn1_txt += '1' if bkn1[i] else '0'
                          print(bkn1_txt)
                          """      
                  elif input_items[0][in_index] == DNB:
                      bkn1 = np.array(input_items[0][in_index+10+34+14 :in_index+10+34+14 +216])
                      bkn2 = np.array(input_items[0][in_index+10+34+252:in_index+10+34+252+216])
                      bkn1 = np.concatenate((bkn1, bkn2))
                      bkn1 = lowerMac.descramble(bkn1, 432, self.m_tetraCell.getScramblingCode())
                      
                      print("DNB")
                      output_items[0][out_index:out_index+len(bkn1)] = bkn1
                      out_index += FRAME_OUT
                      # last byte of FRAME indicates 0 = normal/full speech Frame
                      output_items[0][out_index-1] = 0
                      
                  elif input_items[0][in_index] == DNB_SF:
                      bkn1ValidFlag = False
                      bkn2ValidFlag = False

                      # BKN1 block - DMAC STCH 
                      bkn1 = np.array(input_items[0][in_index+10+34+14 :in_index+10+34+14 +216])
                      bkn1 = lowerMac.descramble(bkn1, 216, self.m_tetraCell.getScramblingCode())
                      bkn1 = lowerMac.deinterleave(bkn1, 216, 101)                                 
                      bkn1 = lowerMac.depuncture23(bkn1, 216)                                      
                      bkn1 = lowerMac.viterbiDecode1614(bkn1)                                      
                      if (lowerMac.checkCrc16Ccitt(bkn1, 140)) :
                          bkn1 = np.array(bkn1[:124])
                          bkn1ValidFlag = True

                      # BKN2 block - DMAC STCH or TCH/S
                      bkn2 = np.array(input_items[0][in_index+10+34+252:in_index+10+34+252+216])
                      bkn2 = lowerMac.descramble(bkn2, 216, self.m_tetraCell.getScramblingCode())
                      bkn2_s = np.array(bkn2)
                      bkn2 = lowerMac.deinterleave(bkn2, 216, 101)
                      bkn2 = lowerMac.depuncture23(bkn2, 216)
                      bkn2 = lowerMac.viterbiDecode1614(bkn2)         
                      if (lowerMac.checkCrc16Ccitt(bkn2, 140)):         # check CRC if FALSE ==> TCH/S
                          bkn2 = np.array(bkn1[:124])
                          bkn2ValidFlag = True;

                      print("DNB_SF")
                  
                      if (bkn1ValidFlag):
                          pass # serviceUpperMac(Pdu(bkn1), DSTCH);                               // first block is stolen for C or U signalling
                      else:    # for debug purpose - display if CRC errors found
                          printf("DNB_SF Burst CRC check errors found BKN1 TN/FN/MN: %u/%u/%u. \n\n", getTime().tn, getTime().fn, getTime().mn);
                      
                      output_items[0][out_index:out_index+216] = np.array([0]*216, dtype='uint8')
                      
                      if (self.m_sfStolenFlag):        # if second-half slot is also stolen
                          output_items[0][out_index+216:out_index+432] = np.array([0]*216, dtype='uint8')
                          if (bkn2ValidFlag):
                              pass #serviceUpperMac(Pdu(bkn2), DSTCH);                           // second block also stolen, reset flag
                          else:
                              printf("DNB_SF Burst CRC check errors found BKN2 TN/FN/MN: %u/%u/%u. \n\n", getTime().tn, getTime().fn, getTime().mn);                    
                      else:
                          pass # serviceUpperMac(vectorExtract(data, 282, 216), DTCH_S);      // SF frame: data length only 216 bits
                          output_items[0][out_index+216:out_index+432] = bkn2_s[:]
                          out_index += len(bkn2)
                      out_index += FRAME_OUT
                      # last byte of FRAME indicates 1 = stolen Frame
                      output_items[0][out_index-1] = 1
                  else:
                      print("Inactive")

                  #output_items[0][in_index:in_index+520] = input_items[0][in_index:in_index+520] 
                  in_index += BURST_IN
                  self.burst_cnt += 1
                  self.m_tetraTime.timeIncrease()

              self.consume(0, in_index) #consume port 0 input
              return out_index
    mode: 'True'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Push per Frame
    marker1: '0'
    name: '"lowerMac"'
    size: view_step-40
    srate: samp_rate
    type: float
    ymax: '3.2'
    ymin: '-0.2'
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0_0, '0']
- [epy_block_0, '0', epy_block_0_2, '0']
- [epy_block_0_0, '0', epy_block_0_1_0, '0']
- [epy_block_0_1_0, '0', epy_block_1, '0']
- [epy_block_0_2, '0', blocks_null_sink_0, '0']
- [epy_block_1, '0', blocks_char_to_float_0_0, '0']
- [epy_block_1, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
