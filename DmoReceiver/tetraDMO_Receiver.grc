options:
  parameters:
    generate_options: qt_gui
    id: tetraDMO_Receiver
    output_language: python
    title: tetraDMO_Receiver
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1-1j, 1+1j, -1-1j, 1-1j]'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {}
- name: decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: freq_offset_khz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,1]'
    label: Baseband offset [kHz]
    type: real
    value: '0'
  states: {}
- name: frequency_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [MHz]
    type: real
    value: '392.875'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ppm_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,2]'
    label: PPM correction
    rangeType: int
    start: '-20'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1280000'
  states: {}
- name: skip_input
  id: variable
  parameters:
    value: int(2040)*0
  states: {}
- name: skip_symbol
  id: variable
  parameters:
    value: 1020*0
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: constel
    modulus: '1'
    step_size: '10e-3'
    type: cma
  states: {}
- name: view_symbols
  id: variable
  parameters:
    value: '255'
  states: {}
- name: TETRA_DMO_MAC_DECODER_0
  id: TETRA_DMO_MAC_DECODER
  parameters:
    parametername_replace_me: You need to fill in your grc/TETRA_DMO_MAC_DECODER.block.yaml
  states: {state: disabled}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '8'
    reference: '1'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ctn008/tetraDMO-Receiver/codec/tetraDMO_s36kBit_r1.uint8
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/ctn008/tetraDMO-Receiver/codec/tetraDMO_s36kIQ_r1.complex64
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: cmath.pi/100.0
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: sps
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*cmath.pi/100.0
    max_dev: '1.5'
    osps: sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      sync block, 480 samples in, 480 samples out
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      IN_STEP = 432
      OUT_STEP = 276

      class tetraChDecoder(gr.basic_block):
          lib = cdll.LoadLibrary('/home/von/new/tetraDMO-Receiver/codec/tetraChDecoderLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          lib.Channel_Decoding.argtypes = [c_int16, c_int16, ND_POINTER, ND_POINTER]
          lib.Channel_Decoding.restype = c_int16
          lib.Desinterleaving_Signalling.argtypes = [ND_POINTER, ND_POINTER]
          lib.Desinterleaving_Signalling.restype = c_int16
          lib.Desinterleaving_Speech.argtypes = [ND_POINTER, ND_POINTER]
          lib.Desinterleaving_Speech.restype = c_int16


          def Channel_Decoding(first_pass, Frame_Stealing, Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Channel_Decoding(first_pass, Frame_Stealing, Input_Frame, Output_Frame)
              return res

          def Desinterleaving_Signalling(Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Desinterleaving_Signalling(Input_Frame, Output_Frame)
              return res

          def Desinterleaving_Speech(Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Desinterleaving_Speech(Input_Frame, Output_Frame)
              return res
          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Tetra ACELP\nChannel Decoder',   # will show up in GRC
                  in_sig =[np.uint8],
                  out_sig=[np.int16]
              )
              self.Loop_counter = 0
              self.first_pass = True
              self.Frame_stealing = False
              self.bfi1 = 0
              self.bfi2 = 0
              self.Reordered_array         = np.array([0]*286, dtype = 'int16')
              self.Interleaved_coded_array = np.array([0]*432, dtype = 'int16')
              self.Coded_array             = np.array([0]*432, dtype = 'int16')
           
          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0

              while (len(input_items[0]) >= in_index + IN_STEP) and (len(output_items[0]) >= out_index + OUT_STEP) :

                  # "0" = 127, "1" = -127
                  if type(input_items[0][0]) == np.uint8:
                      for i in range(432):
                          self.Interleaved_coded_array[i] = -127 if input_items[0][in_index+i] else 127
                  else: #int16                   
                      self.Interleaved_coded_array[0:432] = input_items[0][in_index:in_index+432]
                                                              
                  #self.Frame_stealing = input_items[0][in_index + IN_STEP - 1]

                  if self.Frame_stealing :
                      tetraChDecoder.Desinterleaving_Signalling(self.Interleaved_coded_array[216:], self.Coded_array[216:])
                      self.Coded_array[:216] = self.Interleaved_coded_array[:216]
                  else:
                      tetraChDecoder.Desinterleaving_Speech(self.Interleaved_coded_array, self.Coded_array)

                  self.bfi1 = self.Frame_stealing
                  #if self.bfi1:
                  #    print(f"Frame Nb %d was stolen" %(self.Loop_counter+1))

                  bfi2 = tetraChDecoder.Channel_Decoding(self.first_pass, self.Frame_stealing, self.Coded_array, self.Reordered_array)
                  self.first_pass = False

                  if (self.Frame_stealing==0) and (self.bfi2==1):
                      self.bfi1 = 1

                  self.Loop_counter += 1
                  #if self.bfi2:
                  #    print(f"Frame Nb %d Bfi active" %(self.Loop_counter+1))

                  output_items[0][out_index] = self.bfi1
                  output_items[0][out_index+1:out_index+138] = self.Reordered_array[0:137]
                  output_items[0][out_index+138] = self.bfi2
                  output_items[0][out_index+139:out_index+276] = self.Reordered_array[137:274]

                  #if (not self.bfi1) and (not self.bfi2):
                  #    print(self.Loop_counter, "  full speech frame decoded ok")

                  in_index += IN_STEP
                  out_index += OUT_STEP
                  
              self.consume(0, in_index)
              return out_index
  states: {}
- name: epy_block_0_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      L_FRAME     = 240
      SERIAL_SIZE = 138
      PRM_SIZE    = 24

      synth = np.array([0]*L_FRAME, dtype ='int16')      #/* Synthesis              */
      parm  = np.array([0]*PRM_SIZE, dtype ='int16')     #/* Synthesis parameters   */
      serial= np.array([0]*SERIAL_SIZE, dtype ='int16')  #/* Serial stream          */

      class tetraSpDecoder(gr.basic_block):
          lib = cdll.LoadLibrary('/home/von/new/tetraDMO-Receiver/codec/tetraSrcDecoderLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          lib.Bits2prm_Tetra.argtypes = [ND_POINTER, ND_POINTER]
          lib.Decod_Tetra.argtypes    = [ND_POINTER, ND_POINTER]
          lib.Post_Process.argtypes   = [ND_POINTER, c_int16]

          def Init_Decod_Tetra():
              tetraSpDecoder.lib.Init_Decod_Tetra()
              
          def Bits2prm_Tetra(serial, parm):
              tetraSpDecoder.lib.Bits2prm_Tetra(serial, parm)

          def Decod_Tetra(parm, synth):
              tetraSpDecoder.lib.Decod_Tetra(parm, synth)

          def Post_Process(synth, L_frame):    
              tetraSpDecoder.lib.Post_Process(synth, L_frame)

          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Tetra ACELP\nSpeech Decoder',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[np.float32]
              )
              self.frame = 0

          def general_work(self, input_items, output_items):
              cod_ptr = 0
              raw_ptr = 0

              tetraSpDecoder.Init_Decod_Tetra()
              while (cod_ptr + SERIAL_SIZE <= len(input_items[0])) and (raw_ptr + L_FRAME <= len(output_items[0])):

                  for j in range (SERIAL_SIZE):
                      serial[j] = input_items[0][cod_ptr+j]
                      
                  cod_ptr += SERIAL_SIZE
                  self.frame +=1
                  
                  #print("frame= %d" %self.frame)
                  tetraSpDecoder.Bits2prm_Tetra(serial, parm)
                  tetraSpDecoder.Decod_Tetra(parm, synth)
                  tetraSpDecoder.Post_Process(synth, L_FRAME)

                  for j in range (L_FRAME):
                      output_items[0][raw_ptr+j] = synth[j] / 32768
                  
                  raw_ptr += L_FRAME
              self.consume(0, cod_ptr)
              return raw_ptr
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      class blk(gr.basic_block):
          codingLib = cdll.LoadLibrary('/home/von/new/tetraDMO-Receiver/DmoDecoder/libs/codingLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.uint8, 
                                            ndim=1,
                                            flags="C")
          def service_mac(in_data, in_len, out_data):
              blk.codingLib.service_mac.argtypes = [blk.ND_POINTER, c_size_t, blk.ND_POINTER]
              blk.codingLib.service_mac.restype = c_size_t
              res = blk.codingLib.service_mac(in_data, in_len, out_data)
              return res


          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='DMO\nBurst SYNC',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

          def general_work(self, input_items, output_items):
              in_len = len(input_items[0])
              out_len = len(output_items[0])
              consume_len = in_len if (in_len < (out_len - 510)) else (out_len - 510)
              out_items = blk.service_mac(input_items[0], consume_len, output_items[0])
              self.consume(0, consume_len)
              return out_items
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_khz*1e3
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,12500,12500*0.2)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(samp_rate)/(float(decim)*float(channel_rate))
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '2000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Push per Frame
    name: '"lowerMac"'
    size: '2000'
    srate: audio_rate
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: int(frequency_mhz*1e6-freq_offset_khz*1e3)
    gain0: '1'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: decoder_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: decoder_in
  states: {}

connections:
- [TETRA_DMO_MAC_DECODER_0, '0', epy_block_0_0, '0']
- [analog_feedforward_agc_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_linear_equalizer_0, '0', digital_diff_phasor_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0_0, '0', epy_block_0_2_0, '0']
- [epy_block_0_2_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_2, '0', epy_block_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [mmse_resampler_xx_0, '0', blocks_file_sink_1, '0']
- [mmse_resampler_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', TETRA_DMO_MAC_DECODER_0, '0']
- [virtual_source_0, '0', epy_block_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
